<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\OreSat_WatchdogTest_firmware.ewp</path>
  </project>
  <batchBuild />
</workspace>
